## main/Kconfig.projbuild
```kconfig
menu "Mini TV Pro Clock"
    config CLOCK_HOSTNAME
        string "DHCP hostname"
        default "mintvpro"
endmenu
```
